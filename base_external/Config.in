## base_external/Config.in
```kconfig
menu "My Packages"
source "../base_external/package/aesd-assignments/config.in"
endmenu
```
